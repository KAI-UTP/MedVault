# Keil uVision project Proj_New.uvprojx, settings and files
target Proj_New (6240000::V6.24::ARMCLANG)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(50000000) ELITTLE
  output: Proj_New
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c include: ..\;C:\Users\TUF FA707RC-HX024W\Documents\NUC140BSP_EDU\Library\CMSIS\Include;C:\Users\TUF FA707RC-HX024W\Documents\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Include;C:\Users\TUF FA707RC-HX024W\Documents\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Source;C:\Users\TUF FA707RC-HX024W\Documents\NUC140BSP_EDU\Library\;C:\Users\TUF FA707RC-HX024W\Documents\NUC140BSP_EDU\Library\NUC1xx\Include;C:\Users\TUF FA707RC-HX024W\Documents\NUC140BSP_EDU\Library\NUC1xx-LB_002\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS Group
    C:/Users/TUF FA707RC-HX024W/Documents/NUC140BSP_EDU/Library/CMSIS/Include/: core_cm0.c
    C:/Users/TUF FA707RC-HX024W/Documents/NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
    C:/Users/TUF FA707RC-HX024W/Documents/NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/arm/: startup_NUC1xx.s
  group Source Group
    C:/Users/TUF FA707RC-HX024W/Documents/NUC140BSP_EDU/Library/NUC1xx-LB_002/Source/: LCD.c Seven_Segment.c Scankey.c
    ../: main.c
  group Library Group
    C:/Users/TUF FA707RC-HX024W/Documents/NUC140BSP_EDU/Library/NUC1xx/Source/: GPIO.c SYS.c SPI.c ADC.c UART.c
